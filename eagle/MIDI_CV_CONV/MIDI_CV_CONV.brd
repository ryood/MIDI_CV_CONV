# Repository ryood/MIDI_CV_CONV

## EAGLE design eagle/MIDI_CV_CONV/MIDI_CV_CONV.brd

Parts:
C1, C4: 0.1uF; C025-024X044
C2: 0.1uF; C050-024X044
C3: 100uF; E2,5-7
CN1: PWR9V; B2B-XH-A
CN2: PWR5V; B2B-XH-A
D1: 1S4; DO35-7
IC1: MCP4922
IC2: TLP552; DIL8
IC3: 74HC541N; DIL20
IC4: TD62003; DIL16
JP1: MIDI-IN; 1X02
JP2: MIDI-THRU; 1X03
JP3: GATE-OUT; 1X07
JP4: CV-OUT1; 1X02
JP5: CV-OUT2; 1X02
JP6: TP_CHK; 1X01
JP7: TP_GND; 1X02
JP8: PGM_SW; 1X02
LED1, LED2, LED3, LED4, LED5, LED6: GREEN; LED3MM
R1, R2, R3, R4: 220; 0207/7
R5: 5k; CT6
R6: 4.7k; 0207/7
R7, R8, R9, R10, R11, R12: 1k; 0207/2V
U$1: PRO-MINI-2 (16MHz/5V); PRO-MINI-2

Connections:
+5V: C1.2, C2.2, C3.+, C4.2, CN2.1, IC1.1, IC1.9, IC2.7 (EN), IC2.8 (VCC), IC3.20 (VCC), LED1.A, LED2.A, LED3.A, LED4.A, LED5.A, LED6.A, R2.2, R4.2, R5.E, U$1.VCC
+9V: CN1.1, U$1.RAW
GATE0: IC3.3 (A2), IC4.1 (I1), U$1.D7
GATE1: IC3.4 (A3), IC4.2 (I2), U$1.D6
GATE2: IC3.5 (A4), IC4.3 (I3), U$1.D5
GATE3: IC3.6 (A5), IC4.4 (I4), U$1.D4
GATE4: IC3.7 (A6), IC4.5 (I5), U$1.D3
GATE5: IC3.8 (A7), IC4.6 (I6), U$1.D2
GND: C1.1, C2.1, C3.-, C4.1, CN1.2, CN2.2, IC1.12, IC2.5 (GND), IC3.1 (G1), IC3.9 (A8), IC3.10 (GND), IC3.19 (G2), IC4.7 (I7), IC4.8 (GND), JP2.2, JP3.7, JP4.2, JP5.2, JP7.1, JP7.2, R6.1, U$1.GND
unnamed: D1.A, IC2.3 (C), JP1.2
unnamed: IC3.2 (A1), JP8.2, U$1.RX1
unnamed: IC2.6 (OUT), JP8.1, R2.1
unnamed: D1.C, IC2.2 (A), R1.2
unnamed: JP2.1, R4.1
unnamed: JP2.3, R3.1
unnamed: IC3.18 (Y1), R3.2
unnamed: IC3.17 (Y2), JP3.1
unnamed: IC3.16 (Y3), JP3.2
unnamed: IC3.15 (Y4), JP3.3
unnamed: IC3.14 (Y5), JP3.4
unnamed: IC3.13 (Y6), JP3.5
unnamed: IC3.12 (Y7), JP3.6
unnamed: IC1.3, U$1.D10
unnamed: JP6.1, U$1.D8
unnamed: LED1.K (C), R7.2
unnamed: LED2.K (C), R8.2
unnamed: LED3.K (C), R9.2
unnamed: LED4.K (C), R10.2
unnamed: LED5.K (C), R11.2
unnamed: IC1.4, U$1.D13
unnamed: IC1.5, U$1.D11
unnamed: IC1.8, U$1.D9
unnamed: R5.A, R6.2
unnamed: IC1.14, JP4.1
unnamed: IC1.11, IC1.13, R5.S
unnamed: IC1.10, JP5.1
unnamed: LED6.K (C), R12.2
unnamed: JP1.1, R1.1
unnamed: IC4.16 (O1), R7.1
unnamed: IC4.15 (O2), R8.1
unnamed: IC4.14 (O3), R9.1
unnamed: IC4.13 (O4), R10.1
unnamed: IC4.12 (O5), R11.1
unnamed: IC4.11 (O6), R12.1

Notes on the sheet:
※LED1~6はPIN SOCKETで実装
P4 P5
P4 P2 P5

Board: 2 copper layers, 94.0 x 71.1 mm, 38 parts (0 on the bottom side), 44 nets.

## Commit log

2018-12-10 Add: MIDI_CV_CONV_Test01
2018-12-10 Add: MIDI_CV_CONV_Test02
2018-12-12 Add: MIDI_CV_CONV_Test03
2018-12-12 Add: MIDI_CV_CONV_Test04
2018-12-16 Add: MIDI_IN_Test_Arduino_NANO_LPF.fzz
2018-12-21 Add: MIDI_CV_CONV_Test05
2019-01-04 Add: Eagle files
2019-01-06 Add: Board Design
2019-01-19 Finish Soldering
2019-01-20 Add: MIDI_CV_CONV_Test06
2019-01-24 Add: Test Panel Design
2019-01-25 Update: Block Diagram
2019-03-07 Release
2019-03-07 MIDI_CV_CONV.ino: Impl. setHandleControlChange()
2019-03-07 MIDI_CV_CONV.ino: impl Pitchbend
2019-03-27 Add: 5V Power Supply
2019-05-31 Case
2019-05-31 Add: LED Check
